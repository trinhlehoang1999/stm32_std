# Keil uVision project LED_NEW.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED_NEW
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\HARDWARE\LED;..\STM32F10x_FWLib\inc;..\SYSTEM\sys;..\SYSTEM\delay;..\USER;..\HARDWARE\i2c_lcd;..\SYSTEM\i2c;..\SYSTEM\delay_timer
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CORE
    ../CORE/: startup_stm32f10x_hd.s core_cm3.c
  group HARDWARE
    ../HARDWARE/LED/: LED.c
    ../HARDWARE/i2c_lcd/: i2c_lcd.c
  group STM32F103C8XX
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_tim.c
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay_timer/: delay_timer.c
    ../SYSTEM/i2c/: i2c.c
