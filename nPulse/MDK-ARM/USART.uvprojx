# Keil uVision project USART.uvprojx, settings and files
target USART (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TEMP
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F103xG,USE_HAL_DRIVER,USE_FULL_LL_HAL_DRIVER
  c include: ..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\Drivers\CMSIS\Include;..\Drivers\STM32F1xx_HAL_Driver\Inc;..\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;..\Src;..\Inc;..\SYSTEM\sys;..\HARDWARE\EXTI;..\SYSTEM\usart;..\Drivers\STM32F1xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CORE
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xg.s
  group HAL
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_uart.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group HARDWARE
    ../HARDWARE/EXTI/: exti.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group USER
    ../Src/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c system_stm32f1xx.c
