# Keil uVision project tcs3200_lcd.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED_NEW +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\HARDWARE\LED;..\STM32F10x_FWLib\inc;..\SYSTEM\sys;..\SYSTEM\delay;..\USER;..\HARDWARE\i2c_lcd;..\SYSTEM\i2c;..\SYSTEM\delay_timer;..\HARDWARE\tcs3200
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: startup_stm32f10x_hd.s core_cm3.c
  group HARDWARE
    ../HARDWARE/LED/: LED.c
    ../HARDWARE/i2c_lcd/: i2c_lcd.c
    ../HARDWARE/tcs3200/: tcs3200.c
  group STM32F103C8XX
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_tim.c stm32f10x_exti.c
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay_timer/: delay_timer.c
    ../SYSTEM/i2c/: i2c.c
