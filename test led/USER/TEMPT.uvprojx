# Keil uVision project TEMPT.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TEMPT
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\STM32F10x_FWLib;..\HARDWARE\LED
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group HARDWARE
    ../HARDWARE/LED/: LED.c
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group FWL
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c
